# Keil uVision project TemperatureController.uvproj, settings and files
target TemperatureController (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: temptrans +hex
  c flags: SizeSpeed=1
  c include: ..\Sys;..\User;..\Hardware\ADC;..\Hardware\EEPROM;..\Hardware\GPIO;..\Hardware\INT;..\Hardware\PCA;..\Hardware\PIT;..\Hardware\PWM;..\Hardware\UART;..\HARDWARE\TIMER;..\Peripheral\ad7124_noos;..\Peripheral;..\Hardware\SPI
  group User
    ./: main.c KalmanFilter.c fifoqueue.c modbus.c crc.c
  group Hardware
    ../Hardware/GPIO/: GPIO.c
    ../Hardware/UART/: UART.c
    ../Hardware/SPI/: SPI.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: ADC.c
  group Peripheral
    ../PERIPHERAL/: AD7124_8.c
  group Sys
    ../Sys/: delay.c
